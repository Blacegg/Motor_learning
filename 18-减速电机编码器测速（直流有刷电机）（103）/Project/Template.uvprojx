# Keil uVision project Template.uvprojx, settings and files
target Template (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ..\Libraries\STM32F1xx_HAL_Driver\Inc;..\User;..\Libraries\CMSIS\Device\ST\STM32F1xx\Include;..\Libraries\CMSIS\Include;..\User\BSP_LED;..\User\BSP_KEY;..\User\BSP_BEEP;..\User\BSP_CLKCONFIG;..\User\BSP_EXTI;..\User\BSP_SYSTICK;..\User\BSP_USART;..\User\BSP_TIM;..\User\BSP_MOTOR_CONTROL;..\User\BSP_ENCODE
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARUP
    ../Libraries/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group STM32F1xx_HAL_Driver
    ../Libraries/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_cec.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_eth.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_hcd.c stm32f1xx_hal_i2c.c stm32f1xx_hal_i2s.c stm32f1xx_hal_irda.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_mmc.c stm32f1xx_hal_nand.c stm32f1xx_hal_nor.c stm32f1xx_hal_pccard.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_sd.c stm32f1xx_hal_smartcard.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_sram.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_wwdg.c stm32f1xx_ll_fsmc.c stm32f1xx_ll_sdmmc.c stm32f1xx_ll_usb.c
  group USER
    ../User/: main.c stm32f1xx_it.c
    ../User/BSP_LED/: bsp_led.c
    ../User/BSP_KEY/: bsp_key.c
    ../User/BSP_BEEP/: bsp_beep.c
    ../User/BSP_CLKCONFIG/: bsp_clkconfig.c
    ../User/BSP_EXTI/: bsp_exti.c
    ../User/BSP_SYSTICK/: bsp_systick.c
    ../User/BSP_USART/: bsp_usart.c
    ../User/BSP_ENCODE/: bsp_encode.c
    ../User/BSP_MOTOR_CONTROL/: bsp_motor_control.c
    ../User/BSP_TIM/: bsp_motor_tim.c
  group DOC
    ../Doc/: 工程说明.txt
